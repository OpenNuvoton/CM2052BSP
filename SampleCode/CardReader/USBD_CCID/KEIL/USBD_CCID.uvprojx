# Keil uVision project USBD_CCID.uvprojx, settings and files
target USBD_CCID (6240000::V6.24::ARMCLANG)
  device: CM2052EN8AE Nuvoton
  pack: Nuvoton.NuMicroCM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) IROM2(0x00100000,0x1000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: USBD_CCID
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\CM2052\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SmartcardLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\CM2052\Source\ARM\APROM.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/CM2052/Source/: system_CM2052.c
    ../../../../Library/Device/Nuvoton/CM2052/Source/ARM/: startup_CM2052.c
  group User
    ../: main.c ccid.c Ccid_if.c descriptors.c sc_intf.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c sc.c usbd.c
    ../../../../Library/SmartcardLib/: SmartcardLib.lib
