# Keil uVision project USBD_Printer_And_HID_Transfer.uvprojx, settings and files
target USBD_Printer_And_HID_Transfer (6240000::V6.24::ARMCLANG)
  device: CM2052EN8AE Nuvoton
  pack: Nuvoton.NuMicroCM23_DFP.1.0.3
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) IROM2(0x00100000,0x1000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: USBD_Printer_And_HID_Transfer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\cm2052\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\cm2052\Source\ARM\APROM.sct
  group CMSIS
    ../../../../Library/Device/Nuvoton/cm2052/Source/: system_cm2052.c
    ../../../../Library/Device/Nuvoton/cm2052/Source/ARM/: startup_cm2052.c
  group User
    ../: descriptors.c micro_printer_and_hid_transfer.c main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c sys.c clk.c uart.c
